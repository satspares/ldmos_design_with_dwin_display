# Keil uVision project NEW_C__S5_S4_S3_S2_8283_RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: New_C_8283 +hex
  AfterMake: .\AfterBuildRun.bat
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_M5.A51 Main.c i2c.c i2c.h crc16.c Sys.c Uart.c defines.h adc.h adc.c Functions.h Functions.c
